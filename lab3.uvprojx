# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (6160000::V6.16::.\ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./src/: main.c SysTick.c PIT.c TPM_PWM.c triColorLedPWM.c button.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
